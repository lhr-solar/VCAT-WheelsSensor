File: hardware/Wheels Board/Voltage_Convertor.kicad_sch (KiCad schematic)
At the start: 13 parts, among them U4 TPS5405DR

Commit message: lcsc
Parts:
- D6: P/N MP01EA06 -> SS24FL
